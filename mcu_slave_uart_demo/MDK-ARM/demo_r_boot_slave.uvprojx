# Keil uVision project demo_r_boot_slave.uvprojx, settings and files
target demo_r_boot_slave (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: demo_r_boot_slave +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\BSP;..\Modules\Inc;..\Middlewares\Third_Party\SEGGER_RTT\Config;..\Middlewares\Third_Party\SEGGER_RTT\SEGGER;..\Middlewares\Third_Party\d_flash\murmur3-master;..\Middlewares\Third_Party\d_flash\src;..\Middlewares\Third_Party\r_boot\slaver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/Modules
    ../Modules/Src/: stream_packer.c usr_rboot.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/BSP
    ../BSP/: stm32f103rc_demo_r_boot_slave_flash.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/SEGGER_RTT
    ../Middlewares/Third_Party/SEGGER_RTT/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/d_flash
    ../Middlewares/Third_Party/d_flash/src/: d_flash.c
    ../Middlewares/Third_Party/d_flash/murmur3-master/: murmur3.c
  group Middlewares/r_boot/slave
    ../Middlewares/Third_Party/r_boot/slaver/: crc.c r_boot_slave.c
software components: CMSIS:CORE 4.3.0
